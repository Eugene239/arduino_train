#include <SPI.h>
#include <Ethernet.h>
#include <OneWire.h>

//byte addr1[8][8];

int semaphore[]={7,8,9,11};
int semaphorePower[]={2,3,5,6};

int strelka[]=     {38,40,42,44,46,48,35,37};
int strelkaPower[]={36,34,32,30,28,26,24,22};// 22,24,26,28,30,32,34,36};
int svet[]={48,35,33,31,29,27,25,23,2,3,5,6,7,8,9,11,22,24,26,28,30,32,34,36,38,40,42,44,46,37};
OneWire ds[]={49,41,43,45,47,39,A0,A1,A2,A3,A4,A5,A6,A7,A8,A9,A10,A11,A12,A13,A14,A15};
//uint8_t ip[]      = { 192, 168, 1, 104 };
byte addr1[sizeof(ds)/sizeof(OneWire)][8];
String name= "Arduino #1";

 uint8_t mac[]     = { 0x90, 0xA2, 0xDA, 0x00, 0x51, 0x18 }; //19 
#define MAX_SIZE 32 // maximum packet size
byte packetBuffer[MAX_SIZE]; // buffer to hold incoming packet
int packetSize; // holds received packet size
//стрелка 36,38
//3,7
uint8_t ip[]      = { 192, 168, 1, 160 }; //161
IPAddress server(192, 168, 1, 92);
int port = 5000;
EthernetClient client;
unsigned long time =0;
void setup() {
  for(int i=0; i <sizeof(semaphore)/sizeof(int);i++){
    pinMode(semaphore[i],OUTPUT);
    pinMode(semaphorePower[i],OUTPUT);
    digitalWrite(semaphore[i],HIGH);
    digitalWrite(semaphorePower[i],HIGH);
  }
  for(int i=0; i <sizeof(strelka)/sizeof(int);i++){
    pinMode(strelka[i],OUTPUT);
    pinMode(strelkaPower[i],OUTPUT);
    digitalWrite(strelka[i],HIGH);
    digitalWrite(strelkaPower[i],HIGH);
  }
    for(int i=0; i <sizeof(svet)/sizeof(int);i++){
    pinMode(svet[i],OUTPUT);
    digitalWrite(svet[i],HIGH);
  }
  Serial.begin(9600);
  Serial.println("starting");
  Ethernet.begin(mac,ip);
  delay(1000);
  Serial.println(Ethernet.localIP());
}

